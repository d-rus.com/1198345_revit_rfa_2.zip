Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bathroom-Accessories_DURAVIT-AG_DuraStyle-Wooden-frame-940x440x805-mm-DS.ifc
Time: 2023-04-14T12:00:56
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, DuraStyle Wooden frame 940x440x805 mm - DS9883
ePset_BIMobjectScript - FInish: European Oak Frame - White Shelf - DS988302276; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DuraStyle Wooden frame 940x440x805 mm - DS9883; SKU (BO_prodsku): DuraStyle-Wooden-frame--940x440x805-mm-DS9883; ManufacturName (BO_Manufac): DURAVIT AG; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): Vanity units; ProductGroup (BO_prodgroup): Wooden frame; DesignCountry (BO_designcont): Germany; EditionNumber (BO_edinum): 1; Width (BO_width): 940; Height (BO_height): 805; Depth (BO_depth): 440; Weight (BO_weight): 5; QR (BO_boqrurl): http://bimobject.com/duravit/product/DuraStyle-Wooden-frame--940x440x805-mm-DS9883; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/DuraStyle-Wooden-frame--940x440x805-mm-DS9883; ProductUrl (BO_producturl): https://duravit-public-assets.s3.eu-central-1.amazonaws.com/dpi300/3/9/Duravit_PI-HI_DS988309177_395179_300.jpg; InstallationInstructions (BO_montins): https://duravit-public-assets.s3.eu-central-1.amazonaws.com/6/0/Duravit_MI_60607.pdf; ProductCertification (BO_prodcert): http://pro.duravit.com/p/31653; TechnicalDescription (BO_techcert): http://pro.duravit.com/p/31653; InstructionVideo (BO_youtube): http://pro.duravit.com/p/31653; MaterialMain (BO_mainmat): Wood; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bathroom Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-accessories1; IfcClassification (BO_ifcclas): Furnishing Element; UnspscCode (BO_unspsc): 301815; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20; Uniclass2015Description (BO_uniclass2015_desc): Sanitary fittings and accessories; OmniClassCode (BO_omniclass_code): 23-19 31 17; OmniClassDescription (BO_omniclass_name): Sanitary Room Units; MasterFormat2014Code (BO_masterformat2014_code): 10 28 00; MasterFormat2014Description (BO_masterformat2014_name): Toilet, Bath, and Laundry Accessories; UniFormat2Code (BO_uniformat2_code): E2010; UniFormat2Description (BO_uniformat2_name): Fixed Furnishings; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
